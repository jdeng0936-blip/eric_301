# IAR project Eric301.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc; STM8L15x_StdPeriph_Driver\src; User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Eric301.hex
  ILINK.IlinkOutputFile: Eric301.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  group StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_itc.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_tim4.c stm8l15x_usart.c stm8l15x_wwdg.c
  group User
    User/: eric_driver.c eric_proc.c main.c menu.c printf.c st7565r_lcd.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h

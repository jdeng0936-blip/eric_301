#include "eric_proc.h"

#include <stdarg.h>

// 极简版 itoa_pad
static void itoa_pad(char **buf, uint32_t val, int width, char pad, int is_signed) {
    char temp[12];
    int i = 0;
    
    // 处理负数 (对int16/int32兼容)
    if (is_signed && (int32_t)val < 0) {
        *(*buf)++ = '-';
        val = (uint32_t)(-(int32_t)val);
        width--;
    }
    
    if (val == 0) {
        temp[i++] = '0';
    } else {
        while (val > 0) {
            temp[i++] = (val % 10) + '0';
            val /= 10;
        }
    }
    
    while (width > i) {
        *(*buf)++ = pad;
        width--;
    }
    
    while (i > 0) {
        *(*buf)++ = temp[--i];
    }
}

// 轻量级 sprintf 替代品，丢弃 stdio.h (节省 ~1.5KB Flash)
void mini_sprintf(char *buffer, const char *format, ...) {
    va_list args;
    va_start(args, format);
    char *s;
    uint32_t val;
    int is_long;
    int width;
    char pad;
    
    while (*format) {
        if (*format == '%') {
            format++;
            is_long = 0;
            width = 0;
            pad = ' ';
            
            if (*format == '0') {
                pad = '0';
                format++;
            }
            
            while (*format >= '0' && *format <= '9') {
                width = width * 10 + (*format - '0');
                format++;
            }
            
            if (*format == 'l') {
                is_long = 1;
                format++;
            }
            
            if (*format == 'd') {
                if (is_long) {
                    val = va_arg(args, uint32_t);
                    itoa_pad(&buffer, val, width, pad, 1);
                } else {
                    int ival = va_arg(args, int);
                    itoa_pad(&buffer, (uint32_t)(ival), width, pad, 1);
                }
            } else if (*format == 's') {
                s = va_arg(args, char*);
                while (*s) {
                    *buffer++ = *s++;
                }
            } else {
                *buffer++ = *format;
            }
        } else {
            *buffer++ = *format;
        }
        format++;
    }
    *buffer = '';
    va_end(args);
}

#include "menu.h"
#include "string.h"
#include "eric_driver.h"
#include "stdio.h"
//#include "math.h"  // removed: no longer needed after float->int optimization

TStroke_Rec strokeA =
{
	.tim_trg = 1,
	.tim_s = 0,
	.tim_e = 0,
	.tim_len = 0,
};

TStroke_Rec strokeB =
{
	.tim_trg = 1,
	.tim_s = 0,
	.tim_e = 0,
	.tim_len = 0,
};

TStroke_Rec strokeC =
{
	.tim_trg = 1,
	.tim_s = 0,
	.tim_e = 0,
	.tim_len = 0,
};

uint8_t  single_trg;//单次触发标识

volatile uint32_t ticks = 0; //本系统ticks，在timer2定时器中断内每0.1ms累计
MsgQue MsgSystem;

static Tstat stt[7] = {{0,0,0},{0,0,0},{0,0,0},{0,0,0},{0,0,0},{0,0,0},{0,0,0}}; //雷击数据统计 AD,BD,CD,AB,BC,CD
Trecord recd, lrecd; //雷击记录
uint32_t selfid = 0; //设备ID
uint8_t r485id = 0; //485id

PTK_485M_Cfg   m_cfg;//主机下发配置
PKT_485M_Query c_ackcfg;//从机应答配置ok

PKT_485M_Query m_query;//主机询问数据
PKT_485C_AckQuery c_ackquery;//从机应答实时数据
Rs485u16Rlt r485rlt = {0}; //485发送实时数据包


static volatile uint8_t sysmode = 1; // 设备工作模式 1:电池 0:AC

// 获取系统模式
uint8_t System_GetMode(void)
{
    return sysmode;
}

// 启动时初始化系统模式
void System_InitMode(void)
{
    sysmode = GPIO_ReadInputDataBit(GPIOC, GPIO_Pin_4);
}

// 获取指定相的统计数据指针
Tstat* Record_GetStat(uint8_t phase)
{
    if (phase > 6) phase = 0;
    return &stt[phase];
}
// 获取雷击记录指针
Trecord* Record_GetRecd(void)
{
    return &recd;
}

// 获取历史雷击记录指针
Trecord* Record_GetLRecd(void)
{
    return &lrecd;
}

// 封装保存所有的统计数据
void Storage_SaveAllStats(void)
{
    Save_Stat((uint8_t *)&stt);
}

// 封装保存一次新雷击记录
void Record_SaveNew(uint8_t* timeData, uint32_t phalen)
{
    memcpy((uint8_t *)&recd, timeData, 6);
    recd.pl = phalen;
    Save_Data((uint8_t *)&recd);
}

// 封装加载历史雷击记录
uint8_t Record_LoadHistory(uint8_t mode)
{
    return Load_Data(mode, (uint8_t *)&lrecd);
}






uint8_t rsUbuf[128];//串口接收数据解包
uint8_t pkt1[128];  //用于组包的缓存


//逐位CRC16计算（替代查表法，节省512字节表空间）
uint16_t CRC_GetModbus16(uint8_t *pdata, int len)
{
	uint16_t crc = 0xFFFF;
	uint8_t i;

	while (len--)
	{
		crc ^= *pdata++;
		for (i = 0; i < 8; i++)
		{
			if (crc & 1)
				crc = (crc >> 1) ^ 0xA001;
			else
				crc = crc >> 1;
		}
	}
	return crc;
}

void InitMsg(MsgQue *msgq)
{
	uint8_t i;

	if (msgq == 0)
	{
		return;
	}
	msgq->r = 0;
	msgq->w = 0;
	for (i = 0; i < MSG_LEN; i++)
	{
		msgq->msg[i].msgtype = 0;
		msgq->msg[i].msgval1 = 0;
		msgq->msg[i].msgval2 = 0;
	}
}


void SendMsg(MsgQue *msgq, uint8_t type, uint32_t val1, uint32_t val2)
{
	if (msgq == 0)
	{
		return;
	}
	msgq->msg[msgq->w].msgtype = type;
	msgq->msg[msgq->w].msgval1 = val1;
	msgq->msg[msgq->w].msgval2 = val2;
	msgq->w = (msgq->w + 1) % MSG_LEN;
}

TMSG *RevMsg(MsgQue *msgq)
{
	TMSG *p = 0;

	if (msgq == 0)
	{
		return 0;
	}

	if (msgq->r != msgq->w)
	{
		p = &msgq->msg[msgq->r];
		msgq->r = (msgq->r + 1) % MSG_LEN;
		return p;
	}

	return 0;
}


void A_Fxn(void)
{
	static uint8_t  psta[4] = {0};
	uint8_t i;
	uint32_t raw;

	if (strokeA.tim_trg > 0)
	{
		return;
	}

	psta[0] = psta[1];
	psta[1] = psta[2];
	psta[2] = psta[3];
	psta[3] = GPIO_ReadInputDataBit(GPIOD, GPIO_Pin_5); //每200ms读pin状态,超过1000ms都是高电平，表示一次冲击停止

	for (i = 0; i < 4; i++)
	{
		if (0 == (psta[i] & 0x20))
		{
			i = 0xff;
			break;
		}
	}
	if (i != 0xff)
	{
		memset(psta, 0, 4);
		raw = (strokeA.tim_e >= strokeA.tim_s) ? (strokeA.tim_e - strokeA.tim_s) : 0;
		strokeA.tim_len = (uint32_t)((701UL * raw + 3500UL) / 7000UL);
		strokeA.tim_trg = 1;
		single_trg += 1;
		strokeA.tim_len = (strokeA.tim_len & 0x00ffffff) | (0x01000000); //A相+时长
		SendMsg(&MsgSystem, MSG_COUNT, strokeA.tim_len, strokeA.tim_s); //发送相别+时长+起始时间(用于判断是否是相邻两项同时被雷击)

	}

}


void B_Fxn(void)
{
	static uint8_t  pstb[4] = {0};
	uint8_t i;
	uint32_t raw;

	if (strokeB.tim_trg > 0)
	{
		return;
	}

	pstb[0] = pstb[1];
	pstb[1] = pstb[2];
	pstb[2] = pstb[3];
	pstb[3] = GPIO_ReadInputDataBit(GPIOD, GPIO_Pin_6); //每200ms读pin状态,超过1000ms都是高电平，表示一次冲击停止

	for (i = 0; i < 4; i++)
	{
		if (0 == (pstb[i] & 0x40))
		{
			i = 0xff;
			break;
		}
	}
	if (i != 0xff)
	{
		memset(pstb, 0, 4);
		raw = (strokeB.tim_e >= strokeB.tim_s) ? (strokeB.tim_e - strokeB.tim_s) : 0;
		strokeB.tim_len = (uint32_t)((701UL * raw + 3500UL) / 7000UL);
		strokeB.tim_trg = 1;
		single_trg += 1;
		strokeB.tim_len = (strokeB.tim_len & 0x00ffffff) | (0x02000000);
		SendMsg(&MsgSystem, MSG_COUNT, strokeB.tim_len, strokeB.tim_s);
	}

}


void C_Fxn(void)
{
	static uint8_t  pstc[4] = {0};
	uint8_t i;
	uint32_t raw;

	if (strokeC.tim_trg > 0)
	{
		return;
	}

	pstc[0] = pstc[1];
	pstc[1] = pstc[2];
	pstc[2] = pstc[3];
	pstc[3] = GPIO_ReadInputDataBit(GPIOD, GPIO_Pin_7); //每200ms读pin状态,超过1000ms都是高电平，表示一次冲击停止

	for (i = 0; i < 4; i++)
	{
		if (0 == (pstc[i] & 0x80))
		{
			i = 0xff;
			break;
		}
	}

	if (i != 0xff)
	{
		memset(pstc, 0, 4);
		raw = (strokeC.tim_e >= strokeC.tim_s) ? (strokeC.tim_e - strokeC.tim_s) : 0;
		strokeC.tim_len = (uint32_t)((701UL * raw + 3500UL) / 7000UL);
		strokeC.tim_trg = 1;
		single_trg += 1;
		strokeC.tim_len = (strokeC.tim_len & 0x00ffffff) | (0x04000000);
		SendMsg(&MsgSystem, MSG_COUNT, strokeC.tim_len, strokeC.tim_s);

	}

}

//////////////////////////////////////////rs485////////////////////////////////////////////////////////
uint16_t Rev16(uint16_t val)
{
	uint8_t a, b;
	uint16_t c;

	a = (val >> 8) & 0xff;
	b = val & 0xff;
	c = (b << 8) | a;
	return c;
}

uint8_t crc_verify(uint8_t *p, uint16_t len) //stm8是大端模式
{
	uint16_t crc1 = 0, crc2 = 0;

	memcpy((uint8_t *)&crc1, p + len - 2, 2);
	crc1 = Rev16(crc1);
	crc2 = CRC_GetModbus16(p, len - 2);
	if (crc1 == crc2)
	{
		return 1;
	}
	else
	{
		return 0;
	}
}

//485实时数据包应答
uint16_t Pkt_485ackquery(uint8_t addrID, uint8_t funID, uint16_t saddr, uint16_t offset, Rs485u16Rlt *rlt, uint8_t *packet)
{
	uint16_t len = 0;
	uint16_t crc16 = 0;
	uint16_t rlt16[8];

	if (rlt == NULL)
	{
		return 0;
	}
	if (packet == NULL)
	{
		return 0;
	}
	if (saddr > 7)
	{
		return 0;
	}
	if ((offset == 0) || (offset > 7))
	{
		return 0;
	}


	if ((saddr + offset) > 7) //如果地址加偏移错误，自动修正
	{
		offset = 7 - saddr;
	}

	memset(packet, 0, 128);
	memset((uint8_t *)&c_ackquery, 0, 128);
	c_ackquery.addrID = addrID;
	c_ackquery.funID = funID;

	rlt16[0] = rlt->index;
	rlt16[1] = rlt->phase;
	rlt16[2] = rlt->tlen;
	rlt16[3] = rlt->ym;
	rlt16[4] = rlt->dh;
	rlt16[5] = rlt->ms;
	rlt16[6] = rlt->batt;

	c_ackquery.length = offset * 2; //偏移量从1开始计算

	memcpy(c_ackquery.buf, (uint8_t *)&rlt16[saddr], c_ackquery.length);
	len = 3 + c_ackquery.length;
	memcpy(packet, (uint8_t *)&c_ackquery, len);
	crc16 = CRC_GetModbus16(packet, len);
	crc16 = Rev16(crc16);
	memcpy((packet + len), (uint8_t *)&crc16, 2); //拷贝CRC
	return (len + 2);

}

void Get_Record(uint8_t tag)
{
	uint8_t result = 0;

	if (tag == 0) //如果超时从当前最新的记录开始读取，否则读取下一条记录
	{
		if (data_index.used) //有效数据
		{
			if (data_index.w > 0)
			{
				data_index.r = data_index.w - 1;
			}
			else
			{
				data_index.r = 89;
			}
		}
		else
		{
			data_index.r = 0;
		}
		result = Load_Data(2, (uint8_t *)&lrecd);
	}
	else
	{
		result = Load_Data(0, (uint8_t *)&lrecd);
	}

	if (result)
	{
		r485rlt.index = data_index.r + 1;
		r485rlt.phase = (lrecd.pl >> 24) & 0xff;
		r485rlt.tlen = (lrecd.pl & 0x0000ffff);
		r485rlt.ym = (lrecd.year << 8) | lrecd.mon;
		r485rlt.dh = (lrecd.day << 8) | lrecd.hour;
		r485rlt.ms = (lrecd.min << 8) | lrecd.sec;
		r485rlt.batt = (uint16_t)(Verfin / 100);
	}
}


uint8_t Rs485_GetCfg(uint16_t staddr, uint16_t offset, uint8_t *pbuf)
{
	uint16_t addr = 0, val1 = 0, val2 = 0;

	if (pbuf == NULL)
	{
		return 0;
	}
	if (staddr < 0x8000)
	{
		return 0;
	}
	if (staddr > 0x8005)
	{
		return 0;
	}
	if ((offset == 0) || (offset > 6))
	{
		return 0;
	}

	if ((staddr + offset) > 0x8006) //如果地址加偏移错误，自动修正
	{
		offset = 0x8006 - staddr;
	}

	for (addr = staddr - 0x8000; addr <= offset ; addr++)
	{
		memcpy((uint8_t *)&val1, pbuf, 2);
		val2 = Rev16(val1);

		switch (addr)
		{
			case 0x00:
				adjustdt.dt[0] = (val2 & 0xff);
				break;
			case 0x01:
				adjustdt.dt[1] = (val2 & 0xff);
				break;
			case 0x02:
				adjustdt.dt[2] = (val2 & 0xff);
				break;
			case 0x03:
				adjustdt.dt[3] = (val2 & 0xff);
				break;
			case 0x04:
				adjustdt.dt[4] = (val2 & 0xff);
				break;
			case 0x05:
				adjustdt.dt[5] = (val2 & 0xff);
				break;

			default:
				break;
		}
		pbuf += 2;
	}
	return 1;
}



void Rs485_Proc(void)
{
	static uint8_t temp1 = 0, temp2 = 0, stateU = 0, timeout = 10;
	uint16_t pktlen = 0, recbyte = 0, len1 = 0, sta1 = 0, off1 = 0;

	if (timeout) //2s超时计数
	{
		timeout--;
	}

	while (u1buf.r != u1buf.w)
	{
		temp2 = temp1;
		temp1 = u1buf.recbuf[u1buf.r];
		u1buf.r = (u1buf.r + 1) % UBUFLEN;

		switch (stateU)
		{
			case 2://下发数据,0x10
				if (recbyte >= 128) { // 严格防止缓冲区溢出
					stateU = 0;
					break;
				}
				rsUbuf[recbyte++] = temp1;

				if (recbyte == 7) //数据长度
				{
					pktlen = temp1 + 9; //总数据长度
					if (pktlen > 128) //错误长度
					{
						stateU = 0;
					}
				}

				if ((pktlen > 0) && (recbyte >= pktlen)) //接收到足够包长
				{
					memset((uint8_t *)&m_cfg, 0, 88);
					memcpy((uint8_t *)&m_cfg, rsUbuf, pktlen);
					if (crc_verify((uint8_t *)&m_cfg, pktlen)) //主机数据校验ok
					{
						c_ackcfg.addrID = r485id;
						c_ackcfg.funID = 0x10;
						c_ackcfg.staddr = m_cfg.staddr; //获取用于应答的数据包地址
						c_ackcfg.offset = m_cfg.offset; //获取用于应答的数据偏移量						

						sta1 = Rev16(m_cfg.staddr); //大小端转换
						m_cfg.staddr = sta1;
						off1 = Rev16(m_cfg.offset);
						m_cfg.offset = off1;

						if (Rs485_GetCfg(m_cfg.staddr, m_cfg.offset, m_cfg.buf) > 0)//配置时间
						{
							rtc_set_datetime();
							c_ackcfg.crc = CRC_GetModbus16((uint8_t *)&c_ackcfg, 6);
							c_ackcfg.crc = Rev16(c_ackcfg.crc);//stm8是大端模式
							memcpy(pkt1, (uint8_t *)&c_ackcfg, 8);
							Uart1_Send(pkt1, 10);
						}
					}
					stateU = 0;
				}
				break;


			case 1://下取数据,0x03
				if (recbyte >= 128) { // 严格防止缓冲区溢出
					stateU = 0;
					break;
				}
				rsUbuf[recbyte++] = temp1;
				if (recbyte >= RS485_AQ_PktLen)//一个包长 8bytes
				{
					memset((uint8_t *)&m_query, 0, RS485_AQ_PktLen);
					memcpy((uint8_t *)&m_query, rsUbuf, RS485_AQ_PktLen);

					if (crc_verify((uint8_t *)&m_query, RS485_AQ_PktLen)) //主机数据校验ok
					{
						Get_Record(timeout);
						timeout = 10;
						len1 = Pkt_485ackquery(r485id, 0x03, m_query.staddr, m_query.offset, &r485rlt, pkt1);
						if (len1 > 5)
						{
							Uart1_Send(pkt1, len1);
						}
					}
					stateU = 0;
				}
				break;

			case 0:
				if ((r485id == temp2) && (0x03 == temp1)) //下取数据
				{
					memset(rsUbuf, 0, 128);
					recbyte = 0;
					pktlen = 0;
					rsUbuf[recbyte++] = temp2;
					rsUbuf[recbyte++] = temp1;
					stateU = 1;
				}
				else if ((r485id == temp2) && (0x10 == temp1)) //下发数据
				{
					memset(rsUbuf, 0, 128);
					recbyte = 0;
					pktlen = 0;
					rsUbuf[recbyte++] = temp2;
					rsUbuf[recbyte++] = temp1;
					stateU = 2;
				}
				break;

			default:
				stateU = 0;
				break;
		}
	}
}//用于检测485接口是否接收到有效数据，100ms

void Chk_State(void)
{
	static uint8_t last = 0;

	last = sysmode;
	sysmode = GPIO_ReadInputDataBit(GPIOC, GPIO_Pin_4);
	if (last != sysmode)
	{
		if (sysmode) //电池
		{
			USART_DeInit(USART1);       //复位UART1
			GPIO_Init(GPIOC, 0xEC, GPIO_Mode_Out_PP_Low_Slow);//除PC0，PC1(I2C1)，PC4
		}
		else//AC
		{
			Uart1_Init();
		}
		delay_halt = HALT_TIMEOUT;
	}
}


//======================================================================
// 存储与系统设置单例 (Storage & Settings Singleton)
// 从 menu.c 剥离出来的核心业务逻辑
//======================================================================

// 保存系统设置（语言，设备ID）
void Storage_SaveSettings(uint8_t lang, uint8_t id_b3, uint8_t id_b2, uint8_t id_b1, uint8_t id_b0)
{
    I2C_WriteByte(0xa0,252,id_b3);
    Delay(IIC_TIMEOUT);
    I2C_WriteByte(0xa0,253,id_b2);
    Delay(IIC_TIMEOUT);
    I2C_WriteByte(0xa0,254,id_b1);
    Delay(IIC_TIMEOUT);
    I2C_WriteByte(0xa0,255,id_b0);
    Delay(IIC_TIMEOUT);
    
    I2C_WriteByte(0xa0,80,lang);
    Delay(IIC_TIMEOUT);
}

// 清除历史记录索引
void Storage_ClearHistory(void)
{
    I2C_WriteByte(0xa0,250,data_index.w);
    Delay(IIC_TIMEOUT);
    I2C_WriteByte(0xa0,251,data_index.used);
    Delay(IIC_TIMEOUT);
}

// 恢复出厂设置
// 恢复出厂设置
void Storage_FactoryReset(void)
{
    I2C_WriteByte(0xa0,250,0);
    Delay(IIC_TIMEOUT);
    I2C_WriteByte(0xa0,251,0);
    Delay(IIC_TIMEOUT);
    data_index.w=0;
    data_index.used=0;

    I2C_WriteByte(0xa0,252,0);
    Delay(IIC_TIMEOUT);
    I2C_WriteByte(0xa0,253,0);
    Delay(IIC_TIMEOUT);
    I2C_WriteByte(0xa0,254,0);
    Delay(IIC_TIMEOUT);
    I2C_WriteByte(0xa0,255,1);
    Delay(IIC_TIMEOUT);

    memset((uint8_t *)&stt,0,70);
    Save_Stat((uint8_t *)&stt);

    Delay(IIC_TIMEOUT);
    WWDG_SWReset();
}

// 系统启动时加载所有EEPROM配置到内存
void Storage_Init(void)
{
    uint8_t id[4];

    Load_Stat((uint8_t *)&stt);//读取统计数据
    if ((stt[A].tscount == 0xffff) && (stt[B].tscount == 0xffff) && (stt[C].tscount == 0xffff)) //如果是首次读取，先初始化
        memset((uint8_t *)&stt, 0, 70);

    Delay(IIC_TIMEOUT);
    adjustdt.dt[11] = I2C_ReadByte(0xa0, 80); //语言选择
    language = adjustdt.dt[11];

    Delay(IIC_TIMEOUT);
    data_index.w = I2C_ReadByte(0xa0, 250); //读取保存了的数据索引
    if (data_index.w == 0xff)
        data_index.w = 0;
    Delay(IIC_TIMEOUT);
    data_index.used = I2C_ReadByte(0xa0, 251);
    if (data_index.used == 0xff)
        data_index.used = 0;

    id[0] = I2C_ReadByte(0xa0, 252);
    Delay(IIC_TIMEOUT);
    id[1] = I2C_ReadByte(0xa0, 253);
    Delay(IIC_TIMEOUT);
    id[2] = I2C_ReadByte(0xa0, 254);
    Delay(IIC_TIMEOUT);
    id[3] = I2C_ReadByte(0xa0, 255);

    selfid = id[0] * 1000000 + id[1] * 10000 + id[2] * 100 + id[3];
    if (selfid > 99999999)
        selfid = 1;
    r485id = (selfid & 0xff);
}
